# Keil uVision project volleyball2_H7.uvprojx, settings and files
target volleyball2_H7 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: volleyball2_H7 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,USE_FREERTOS
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../can;../control;../chassis_local;../unitree_motor;../cybergear_motor;../../../shared
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../chassis_local;../../../shared
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c usart.c spi.c tim.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
  group can
    ../can/: chassis_path_task.c chassis_path_task.h chassis_task.c chassis_task.h dji_motor.c dji_motor.h fdcan_bsp.c fdcan_bsp.h hmi_panel.c hmi_panel.h mechanism_task.c mechanism_task.h pid.c pid.h remote_driver.c remote_driver.h robot_data.c robot_data.h Task_command.c Task_command.h planner_tuning_protocol.c planner_tuning_protocol.h
  group PAN_control
    ../control/: Pan_Tilt_control.c Pan_Tilt_control.h chassis_cybergear.c chassis_cybergear.h
    ../ramp/: ramp.c ramp.h
  group cybergear
    ../cybergear_motor/: cybergear_motor.c cybergear_motor.h trajectory_planner.c trajectory_planner.h cybergear_speed_planner.c cybergear_speed_planner.h
  group unitree
    ../unitree_motor/: crc_ccitt.c crc_ccitt.h gom_protocol.c gom_protocol.h unitree_motor.c unitree_motor.h
  group chassis_local
    ../chassis_local/: h7_vesc.c h7_vesc.h h7_vesc_rx.c h7_vesc_rx.h local_chassis_control.c local_chassis_control.h local_kinematics.c local_kinematics.h local_safety_guardian.c local_safety_guardian.h
software components: CMSIS:CORE 5.6.0
